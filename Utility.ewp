# IAR project Utility.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: C:\Condivisi\4H\TPS\Utility\Debouncer; C:\Condivisi\4H\TPS\Utility\Misc; C:\Condivisi\4H\TPS\Utility\LinkedList; C:\Condivisi\4H\TPS\Utility\Timer; C:\Condivisi\4H\TPS\Utility\SevenSegment; C:\Condivisi\4H\TPS\Utility\ADC12; C:\Condivisi\4H\TPS\Utility\Serial; C:\Condivisi\4H\TPS\Utility\CircularBuffer
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group ADC12
    ADC12/: adc12.c adc12.h
  group CircularBuffer
    CircularBuffer/: circularBuffer.c circularBuffer.h
  group Debouncer
    Debouncer/: debouncer.c debouncer.h
  group I2C
    I2C/: i2c.c i2c.h
  group LinkedList
    LinkedList/: linkedList.c linkedList.h
  group Misc
    Misc/: utility.h
  group MultiplexedSevenSegment
    MultiplexedSevenSegment/: muxSevenSeg.c muxSevenSeg.h
  group Serial
    Serial/: serial.c serial.h
  group SevenSegment
    SevenSegment/: sevenSegment.c sevenSegment.h
  group Timer
    Timer/: timer.c timer.h
